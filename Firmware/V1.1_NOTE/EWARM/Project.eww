<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\V1.1_NOTE.ewp</path>
  </project>
  <batchBuild />
</workspace>
